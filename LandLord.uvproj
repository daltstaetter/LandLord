# Keil uVision project LandLord.uvproj, settings and files
target Worx-Debug (ARM-ADS)
  device: LPC1788 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LandLord
  AfterMake: $K\ARM\BIN\ElfDwT !L BASEADDRESS(0x10000)
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output="$L@L.bin" !L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUGCONSOLE
  c include: .;.\FreeRTOS;.\FreeRTOS\keil;.\u8g;.\FreeRTOS\FreeRTOS-Plus-CLI;.\FreeRTOS\FreeRTOS-Plus-IO\Include;.\FreeRTOS\FreeRTOS-Plus-IO\Device\LPC17xx\SupportedBoards;.\FreeRTOS\FreeRTOS-Plus-IO\Device\LPC17xx\lpc17xx.cmsis.driver.library\Include;.\common
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Common
    ./common/: startup_LPC17xx.s core_cm3.c system_LPC17xx.c
  group Main
    ./: keypad.c lcd.c main.c screen.c sensor.c console.c powermgmt.c motorctrl.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_5.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/keil/: port.c
  group u8g
    ./u8g/: u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_io.c u8g_com_null.c u8g_com_std_sw_spi.c u8g_cursor.c u8g_delay.c u8g_dev_st7565_nhd_c12864.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_virtual_screen.c
target LPCXpresso-Debug (ARM-ADS)
  device: LPC1769 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LandLord
  AfterMake: $K\ARM\BIN\ElfDwT !L BASEADDRESS(0x0000)
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output="$L@L.bin" !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .;.\FreeRTOS;.\FreeRTOS\keil;.\u8g;.\FreeRTOS\FreeRTOS-Plus-CLI;.\FreeRTOS\FreeRTOS-Plus-IO\Include;.\FreeRTOS\FreeRTOS-Plus-IO\Device\LPC17xx\SupportedBoards;.\FreeRTOS\FreeRTOS-Plus-IO\Device\LPC17xx\lpc17xx.cmsis.driver.library\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
